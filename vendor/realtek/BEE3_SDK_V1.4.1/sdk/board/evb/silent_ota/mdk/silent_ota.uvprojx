# Keil uVision project silent_ota.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat @L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_define.h --preinclude mem_config.h --bss_threshold=0
  c include: ..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\inc\app;..\..\..\..\inc\platform;..\..\..\..\inc\platform\cmsis;..\..\..\..\inc\os;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\peripheral;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\src\ble\profile\server;..\..\..\..\src\dfu;..\..\..\..\src\app\silent_ota;..\..\..\..\inc\os\system_trace;..\..\silent_ota
  asm misc: --cpreproc
  asm include: ..\..\..\..\inc\platform
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../bin/mdk/: rom.lib gap_utils.lib bee3_sdk.lib system_trace.lib
  group cmsis
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
  group app
    ../../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../../src/app/silent_ota/: app_task.c silent_ota_application.c main.c reset_watch_dog_timer.c
    ../../../../src/platform/: dfu_flash.c system_trace.c
  group normal_ota
    ../../../../src/dfu/: dfu_application.c dfu_main.c dfu_task.c
  group profile
    ../../../../src/ble/profile/server/: bas.c dis.c ota_service.c dfu_service.c
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_rcc.c rtl876x_pinmux.c rtl876x_nvic.c rtl876x_aon_wdg.c rtl876x_tim.c
