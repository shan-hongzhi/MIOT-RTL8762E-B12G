# Keil uVision project peripheral_privacy.uvprojx, settings and files
target ble_peripheral_privacy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\..\tool\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat  @L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\inc\app;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\os;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\src\mcu\module\data_uart_cmd;..\..\..\..\src\ble\privacy;..\..\..\..\src\sample\ble_peripheral_privacy;..\..\ble_peripheral_privacy
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../bin/mdk/: ROM.lib gap_utils.lib bee3_sdk.lib
  group cmsis
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_rcc.c rtl876x_uart.c
  group profile
    ../../../../src/ble/profile/server/: simple_ble_service.c bas.c
  group app
    ../../../../src/sample/ble_peripheral_privacy/: app_task.c main.c peripheral_privacy_app.c
    ../../../../src/ble/privacy/: privacy_mgnt.c
    ../../../../src/mcu/rtl876x/: overlay_mgr.c
  group user_cmd
    ../../../../src/sample/ble_peripheral_privacy/: user_cmd.c
    ../../../../src/mcu/module/data_uart_cmd/: data_uart.c user_cmd_parse.c
